// Host-side unit tests for the HID Report Map parser used by the HID
// Keyboard Host to identify a boot-compatible 6KRO keyboard input report.

#include "EspBleHidReportMap.h"

#include <cstdio>

namespace
{
int failures = 0;

void check(const char *name, bool condition)
{
  if (!condition)
  {
    std::printf("FAIL %s\n", name);
    ++failures;
  }
}

// The report map EspBleHidKeyboardDevice generates (report ID 1).
const uint8_t espBleDeviceMap[] = {
  0x05, 0x01, 0x09, 0x06, 0xa1, 0x01, 0x85, 0x01,
  0x05, 0x07, 0x19, 0xe0, 0x29, 0xe7, 0x15, 0x00, 0x25, 0x01,
  0x75, 0x01, 0x95, 0x08, 0x81, 0x02,
  0x95, 0x01, 0x75, 0x08, 0x81, 0x01,
  0x95, 0x06, 0x75, 0x08, 0x15, 0x00, 0x25, 0x65,
  0x05, 0x07, 0x19, 0x00, 0x29, 0x65, 0x81, 0x00,
  0x95, 0x05, 0x75, 0x01, 0x05, 0x08, 0x19, 0x01, 0x29, 0x05, 0x91, 0x02,
  0x95, 0x01, 0x75, 0x03, 0x91, 0x01,
  0xc0,
};

// Same keyboard, but with the common alternative item ordering seen on
// commercial keyboards: usage range declared before report size/count, and
// report size before report count.
const uint8_t reorderedMap[] = {
  0x05, 0x01, 0x09, 0x06, 0xa1, 0x01, 0x85, 0x01,
  0x05, 0x07, 0x19, 0xe0, 0x29, 0xe7, 0x15, 0x00, 0x25, 0x01,
  0x75, 0x01, 0x95, 0x08, 0x81, 0x02,
  0x75, 0x08, 0x95, 0x01, 0x81, 0x01,
  0x05, 0x07, 0x19, 0x00, 0x29, 0x65, 0x15, 0x00, 0x25, 0x65,
  0x75, 0x08, 0x95, 0x06, 0x81, 0x00,
  0x05, 0x08, 0x19, 0x01, 0x29, 0x05, 0x75, 0x01, 0x95, 0x05, 0x91, 0x02,
  0x75, 0x03, 0x95, 0x01, 0x91, 0x01,
  0xc0,
};

// HID 1.11 Appendix E.6 boot keyboard: no report ID, LED output declared
// between the modifier input and the key array input.
const uint8_t bootKeyboardMap[] = {
  0x05, 0x01, 0x09, 0x06, 0xa1, 0x01,
  0x05, 0x07, 0x19, 0xe0, 0x29, 0xe7, 0x15, 0x00, 0x25, 0x01,
  0x75, 0x01, 0x95, 0x08, 0x81, 0x02,
  0x95, 0x01, 0x75, 0x08, 0x81, 0x01,
  0x95, 0x05, 0x75, 0x01, 0x05, 0x08, 0x19, 0x01, 0x29, 0x05, 0x91, 0x02,
  0x95, 0x01, 0x75, 0x03, 0x91, 0x01,
  0x95, 0x06, 0x75, 0x08, 0x15, 0x00, 0x25, 0x65,
  0x05, 0x07, 0x19, 0x00, 0x29, 0x65, 0x81, 0x00,
  0xc0,
};

// Keyboard (report ID 1) plus Consumer Control (report ID 2), consumer
// collection declared FIRST so naive "first report" selection is wrong.
const uint8_t consumerComboMap[] = {
  // Consumer Control collection, report ID 2.
  0x05, 0x0c, 0x09, 0x01, 0xa1, 0x01, 0x85, 0x02,
  0x15, 0x00, 0x26, 0xff, 0x03, 0x19, 0x00, 0x2a, 0xff, 0x03,
  0x75, 0x10, 0x95, 0x01, 0x81, 0x00,
  0xc0,
  // Keyboard collection, report ID 1.
  0x05, 0x01, 0x09, 0x06, 0xa1, 0x01, 0x85, 0x01,
  0x05, 0x07, 0x19, 0xe0, 0x29, 0xe7, 0x15, 0x00, 0x25, 0x01,
  0x75, 0x01, 0x95, 0x08, 0x81, 0x02,
  0x95, 0x01, 0x75, 0x08, 0x81, 0x01,
  0x95, 0x06, 0x75, 0x08, 0x15, 0x00, 0x25, 0x65,
  0x05, 0x07, 0x19, 0x00, 0x29, 0x65, 0x81, 0x00,
  0x05, 0x08, 0x19, 0x01, 0x29, 0x05, 0x75, 0x01, 0x95, 0x05, 0x91, 0x02,
  0x75, 0x03, 0x95, 0x01, 0x91, 0x01,
  0xc0,
};

// Boot mouse: contains input reports but no keyboard.
const uint8_t mouseMap[] = {
  0x05, 0x01, 0x09, 0x02, 0xa1, 0x01, 0x09, 0x01, 0xa1, 0x00,
  0x05, 0x09, 0x19, 0x01, 0x29, 0x03, 0x15, 0x00, 0x25, 0x01,
  0x95, 0x03, 0x75, 0x01, 0x81, 0x02,
  0x95, 0x01, 0x75, 0x05, 0x81, 0x01,
  0x05, 0x01, 0x09, 0x30, 0x09, 0x31, 0x15, 0x81, 0x25, 0x7f,
  0x75, 0x08, 0x95, 0x02, 0x81, 0x06,
  0xc0, 0xc0,
};

const uint8_t otherTypesMap[] = {
  // Mouse ID 2.
  0x05,0x01, 0x09,0x02, 0xa1,0x01, 0x85,0x02, 0x75,0x08, 0x95,0x04, 0x81,0x02, 0xc0,
  // Gamepad ID 3.
  0x05,0x01, 0x09,0x05, 0xa1,0x01, 0x85,0x03,
  0x15,0x81, 0x25,0x7f, 0x09,0x30, 0x09,0x31, 0x09,0x32,
  0x09,0x35, 0x09,0x33, 0x09,0x34, 0x75,0x08, 0x95,0x06, 0x81,0x02,
  0x15,0x00, 0x25,0x08, 0x09,0x39, 0x75,0x08, 0x95,0x01, 0x81,0x02,
  0x05,0x09, 0x19,0x01, 0x29,0x20, 0x15,0x00, 0x25,0x01,
  0x75,0x01, 0x95,0x20, 0x81,0x02, 0xc0,
  // Consumer Control ID 4.
  0x05,0x0c, 0x09,0x01, 0xa1,0x01, 0x85,0x04, 0x75,0x10, 0x95,0x01, 0x81,0x00, 0xc0,
  // System Control ID 5.
  0x05,0x01, 0x09,0x80, 0xa1,0x01, 0x85,0x05, 0x75,0x08, 0x95,0x01, 0x81,0x00, 0xc0,
  // Vendor-defined ID 6, 8-byte Input / Output / Feature.
  0x06,0x00,0xff, 0x09,0x01, 0xa1,0x01, 0x85,0x06,
  0x15,0x00, 0x26,0xff,0x00, 0x75,0x08,
  0x09,0x01, 0x95,0x08, 0x81,0x02,
  0x09,0x02, 0x95,0x08, 0x91,0x02,
  0x09,0x03, 0x95,0x08, 0xb1,0x02, 0xc0,
};
} // namespace

int main()
{
  {
    const EspBleHidKeyboardReportMapInfo info =
      espBleParseKeyboardReportMap(espBleDeviceMap, sizeof(espBleDeviceMap));
    check("device map found", info.keyboardFound);
    check("device map has report id", info.hasReportId);
    check("device map report id", info.reportId == 1);
    check("device map led output", info.hasLedOutput);
  }
  {
    const EspBleHidKeyboardReportMapInfo info =
      espBleParseKeyboardReportMap(reorderedMap, sizeof(reorderedMap));
    check("reordered map found", info.keyboardFound);
    check("reordered map report id", info.hasReportId && info.reportId == 1);
    check("reordered map led output", info.hasLedOutput);
  }
  {
    const EspBleHidKeyboardReportMapInfo info =
      espBleParseKeyboardReportMap(bootKeyboardMap, sizeof(bootKeyboardMap));
    check("boot map found", info.keyboardFound);
    check("boot map has no report id", !info.hasReportId);
    check("boot map led output", info.hasLedOutput);
  }
  {
    const EspBleHidKeyboardReportMapInfo info =
      espBleParseKeyboardReportMap(consumerComboMap, sizeof(consumerComboMap));
    check("combo map found", info.keyboardFound);
    check("combo map picks keyboard id", info.hasReportId && info.reportId == 1);
  }
  {
    const EspBleHidKeyboardReportMapInfo info =
      espBleParseKeyboardReportMap(mouseMap, sizeof(mouseMap));
    check("mouse map not a keyboard", !info.keyboardFound);
  }
  {
    const EspBleHidKeyboardReportMapInfo info = espBleParseKeyboardReportMap(nullptr, 0);
    check("empty map not a keyboard", !info.keyboardFound);
  }
  {
    const EspBleHidReportMapInfo info =
      espBleParseHidReportMap(consumerComboMap, sizeof(consumerComboMap));
    check("generic combo has two reports", info.count == 2);
    check("generic combo keyboard", info.kindForReportId(1) == EspBleHidReportKind::Keyboard);
    check("generic combo consumer", info.kindForReportId(2) == EspBleHidReportKind::ConsumerControl);
  }
  {
    const EspBleHidReportMapInfo info = espBleParseHidReportMap(mouseMap, sizeof(mouseMap));
    check("generic mouse found", info.count == 1 &&
      info.entries[0].kind == EspBleHidReportKind::Mouse && !info.entries[0].hasReportId);
    check("generic mouse input length", info.entries[0].inputByteLength() == 3);
    const uint8_t report[] = {0x05, 0xf7, 0x06};
    bool xFound = false;
    bool yFound = false;
    for (size_t index = 0; index < info.fieldCount; ++index)
    {
      if (info.fields[index].usagePage == 1 && info.fields[index].usage == 0x30)
        xFound = espBleHidReadFieldValue(info.fields[index], report, sizeof(report)) == -9;
      if (info.fields[index].usagePage == 1 && info.fields[index].usage == 0x31)
        yFound = espBleHidReadFieldValue(info.fields[index], report, sizeof(report)) == 6;
    }
    check("generic mouse x parse", xFound);
    check("generic mouse y parse", yFound);
  }
  {
    const EspBleHidReportMapInfo info =
      espBleParseHidReportMap(otherTypesMap, sizeof(otherTypesMap));
    check("generic other types count", info.count == 5);
    check("generic mouse id", info.kindForReportId(2) == EspBleHidReportKind::Mouse);
    check("generic gamepad id", info.kindForReportId(3) == EspBleHidReportKind::Gamepad);
    check("generic consumer id", info.kindForReportId(4) == EspBleHidReportKind::ConsumerControl);
    check("generic system id", info.kindForReportId(5) == EspBleHidReportKind::SystemControl);
    check("generic vendor id", info.kindForReportId(6) == EspBleHidReportKind::Vendor);
    bool vendorLength = false;
    for (size_t index = 0; index < info.count; ++index)
      if (info.entries[index].kind == EspBleHidReportKind::Vendor)
        vendorLength = info.entries[index].inputByteLength() == 8;
    check("generic vendor input length", vendorLength);
    bool gamepadLength = false;
    size_t gamepadFields = 0;
    bool gamepadX = false;
    const uint8_t report[] = {10, static_cast<uint8_t>(-20), 0, 0, 0, 0, 1, 3, 0, 0, 0};
    for (size_t index = 0; index < info.count; ++index)
      if (info.entries[index].kind == EspBleHidReportKind::Gamepad)
        gamepadLength = info.entries[index].inputByteLength() == sizeof(report);
    for (size_t index = 0; index < info.fieldCount; ++index)
    {
      if (info.fields[index].kind != EspBleHidReportKind::Gamepad) continue;
      ++gamepadFields;
      if (info.fields[index].usagePage == 1 && info.fields[index].usage == 0x30)
        gamepadX = espBleHidReadFieldValue(info.fields[index], report, sizeof(report)) == 10;
    }
    check("generic gamepad input length", gamepadLength);
    check("generic gamepad field count", gamepadFields == 39);
    check("generic gamepad x parse", gamepadX);
  }
  {
    // Truncated mid-item: must not read out of bounds or crash.
    const uint8_t truncated[] = {0x05, 0x01, 0x09, 0x06, 0xa1, 0x01, 0x19};
    const EspBleHidKeyboardReportMapInfo info =
      espBleParseKeyboardReportMap(truncated, sizeof(truncated));
    check("truncated map not a keyboard", !info.keyboardFound);
  }

  if (failures != 0)
  {
    std::printf("%d check(s) failed\n", failures);
    return 1;
  }
  std::puts("OK");
  return 0;
}
